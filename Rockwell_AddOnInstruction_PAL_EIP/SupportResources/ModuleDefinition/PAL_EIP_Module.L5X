(* Logix 5000 Module export PAL_EIP_Module; software revision 37.00 *)

MODULES
   PAL_EIP_Module : PAL-EIP (Ethernet 192.168.0.51, rev 2.2, StandardDataDriven RPI 250 ms)
END_MODULES
